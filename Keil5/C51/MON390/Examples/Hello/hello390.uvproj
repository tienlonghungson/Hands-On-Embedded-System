# Keil uVision project hello390.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS80C390 Dallas Semiconductor
  cpu: IRAM(0 - 0xFF) CLOCK(40000000) MOD_CONT MODDA MODDP2 XRAM (0xF000 - 0xFFFF)
  output: Hello390
  c flags: Optimize=8 SizeSpeed=1
  c define: MONITOR
  asm define: MONITOR
  group Source Group 1
    ./: START390.A51 hello.c
