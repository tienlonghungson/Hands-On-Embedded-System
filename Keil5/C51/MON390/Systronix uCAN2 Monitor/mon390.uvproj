# Keil uVision project mon390.uvproj, settings and files
target uCAN2 (MCS-51)
  device: DS80C390 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(40000000) MOD_CONT MODDA MODDP2 XRAM (0xF000-0xFFFF)
  output: mon390 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: INSTALL.A51
    ../: mon390.LIB
  group Documentation
    ./: Abstract.txt
