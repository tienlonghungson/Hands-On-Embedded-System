# Keil uVision project hellomon.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS80C400 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(75000000) MOD_CONT MODDA MODDP2 XRAM (0xE000-0xFFFF)
  output: hellomon
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: startup400.a51 main.c
