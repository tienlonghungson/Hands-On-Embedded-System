# Keil uVision project LCD.uvproj, settings and files
target Simulator (MCS-51)
  device: AT89C51SND1 Atmel
  cpu: IROM(0-0xFFFF) IRAM(0-0xFF) XRAM(0-0x7FF) CLOCK(24000000) MODP2
  output: LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
  group LCD Driver
    ./: lcd_io.c
target SND1 Demoboard (MCS-51)
  device: AT89C51SND1 Atmel
  cpu: as above
  output: LCD
  c flags: Optimize=8 SizeSpeed=1
  c define: MONITOR
  asm define: MONITOR=1
