# Keil uVision project Monitor.uvproj, settings and files
target Monitor for Flash (MCS-51)
  device: AT89C51ED2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x6FF) CLOCK(33000000) MODP2
  output: Monitor +hex
  c flags: Optimize=8 SizeSpeed=1
  group Configuration
    ./: CONFIG.INC
  group Monitor Code
    ./: INSTALL.A51 MON51.LIB
  group Documentation
    ./: ABSTRACT.TXT
