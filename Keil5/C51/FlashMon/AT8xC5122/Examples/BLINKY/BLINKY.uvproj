# Keil uVision project BLINKY.uvproj, settings and files
target Simulator (MCS-51)
  device: AT8xC5122 Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0x7FFF) CLOCK(16000000) MODP2
  output: BLINKY
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: BLINKY.C STARTUP.A51
  group Documentation
    ./: ABSTRACT.TXT
target FlashMon (MCS-51)
  device: AT8xC5122 Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x7FFF) IROM(0-0x7FFF) CLOCK(16000000) MODP2
  output: BLINKY +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: MONITOR
  asm define: MONITOR=1
