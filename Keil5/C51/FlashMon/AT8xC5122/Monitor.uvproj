# Keil uVision project Monitor.uvproj, settings and files
target Monitor for Flash (MCS-51)
  device: AT8xC5122 Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0x7FFF) CLOCK(16000000) MODP2
  output: Monitor +hex
  c flags: Optimize=8 SizeSpeed=1
  group Configuration
    ./: CONFIG.INC
  group Monitor Code
    ./: INSTALL.A51 MON51.LIB
  group Documentation
    ./: ABSTRACT.TXT
