# Keil uVision project RTX_EX1.uvproj, settings and files
target RTX51 Tiny Ex1 (MCS-51)
  device: 80C32 NXP (founded by Philips)
  cpu: IRAM(0-0xFF)  CLOCK(33000000)
  output: RTX_EX1
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: RTX_EX1.C ABSTRACT.TXT Conf_tny.A51
