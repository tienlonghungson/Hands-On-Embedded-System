# Keil uVision project Banking.uvproj, settings and files
target Source Files (MCS-51)
  device: P89C51RD2xx NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: Banking
  c flags: Optimize=8 SizeSpeed=1
  group Source File
    ./: Task0.c Task1.c Task2.c Task3.c
  group System Files
    ./: startup.a51 l51_bank.a51 Conf_tny.a51
  group Documentation
    ./: Abstract.txt
