# Keil uVision project TRAFFIC.uvproj, settings and files
target Demo - Simulator (MCS-51)
  device: P89LPC932 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM (0-0x1FF) CLOCK(12000000) MODP2
  output: traffic
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./: TRAFFIC.C SERIAL.C GETLINE.C Conf_tny.A51 START900.A51
  group Documentation
    ./: ABSTRACT.TXT
target Simulator (MCS-51)
  device: P89LPC932 NXP (founded by Philips)
  cpu: as above
  output: traffic
  c flags: Optimize=6 SizeSpeed=1
target MCB900 - Run (MCS-51)
  device: P89LPC932 NXP (founded by Philips)
  cpu: as above
  output: traffic
  c flags: Optimize=6 SizeSpeed=1
target EPM900 - Emulator (MCS-51)
  device: P89LPC935 NXP (founded by Philips)
  cpu: as above
  output: traffic
  c flags: Optimize=6 SizeSpeed=1
