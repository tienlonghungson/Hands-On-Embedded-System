# Keil uVision project RtxTiny2.uvproj, settings and files
target Non Banking (MCS-51)
  device: 83/87C51FA Intel
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) CLOCK(33000000)
  output: RTX51TNY (library)
  AfterMake: CopyLib.BAT
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: Version.a51 Copyright.a51 Conf_tny.a51 Conf_tny_Banking.A51 os_create.a51 os_delete.a51 os_clear_signal.a51 os_send_signal.a51 os_running_task.a51 os_set_ready.a51 os_reset_interval.a51 os_wait.a51
  group Documentation
    ../: ReadMe.TXT
target Code Banking (MCS-51)
  device: 83/87C51FA Intel
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) CLOCK(33000000)
  output: RTX51BT (library)
  AfterMake: CopyLib.bat
  c flags: Optimize=8 SizeSpeed=1
  asm define: CODE_BANKING=1
