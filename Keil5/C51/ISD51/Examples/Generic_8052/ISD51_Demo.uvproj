# Keil uVision project ISD51_Demo.uvproj, settings and files
target ISD51 Demo (MCS-51)
  device: P89C664 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xFFFF) CLOCK(33000000) MODP2
  output: ISD51_Demo
  c flags: Optimize=8 SizeSpeed=1
  group Application Source Files
    ./: Test.c
  group ISD51 Files
    ./: ISD51.A51 ISD51.H
