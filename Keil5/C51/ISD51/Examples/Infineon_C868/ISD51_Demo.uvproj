# Keil uVision project ISD51_Demo.uvproj, settings and files
target ISD51 Demo - SK868 (MCS-51)
  device: C868 Infineon
  cpu: IRAM(0-0xFF) XRAM(0xFF00-0xFFFF) IROM(0-0x1FFF) CLOCK(40000000)
  output: ISD51_Demo +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SK868
  group Application Source Files
    ./: Test.c
  group ISD51 Files
    ./: ISD51.A51 ISD51.H
  group Documentation
    ./: Abstract.txt
target ISD51 Demo - MiniC868 (MCS-51)
  device: C868 Infineon
  cpu: as above
  output: ISD51_Demo +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: MINIC868
