# Keil uVision project ISD51_Demo.uvproj, settings and files
target ISD51 Demo (MCS-51)
  device: DS89C440 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(50000000) MODDP2
  output: ISD51_Demo +hex
  c flags: Optimize=9 SizeSpeed=1
  group Application Source Files
    ./: Test.c START4XX.A51
  group ISD51 Files
    ./: ISD51.A51 ISD51.H
target ISD51 Demo Simulation (MCS-51)
  device: DS89C440 Dallas Semiconductor
  cpu: as above
  output: ISD51_Demo +hex
  c flags: Optimize=9 SizeSpeed=1
