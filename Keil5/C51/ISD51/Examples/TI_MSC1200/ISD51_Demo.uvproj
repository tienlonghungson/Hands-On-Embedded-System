# Keil uVision project ISD51_Demo.uvproj, settings and files
target ISD51 Demo (22.1184MHz) (MCS-51)
  device: MSC1210Y4 Texas Instruments
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM (0x00-0x3FF) CLOCK(24000000) MODDP2
  output: ISD51_Demo +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: ISD51
  group Application Source Files
    ./: Test.c HWCfr.a51 MSC1200_ROM.A51
  group ISD51 Files
    ./: ISD51.h ISD51.A51
  group Documentation
    ./: Abstract.txt
