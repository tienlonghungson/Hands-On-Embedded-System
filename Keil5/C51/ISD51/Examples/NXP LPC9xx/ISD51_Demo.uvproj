# Keil uVision project ISD51_Demo.uvproj, settings and files
target ISD51 Demo - MCB900 (MCS-51)
  device: P89LPC935 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM (0-0x1FF) CLOCK(12000000) MODP2
  output: ISD51_Demo +hex
  c flags: Optimize=9 SizeSpeed=1
  group Application Source Files
    ./: Test.c START900.A51
  group ISD51 Files
    ./: ISD51.A51 ISD51.H
  group Documentation
    ./: Abstract.txt
