# Keil uVision project ISD51_Demo.uvproj, settings and files
target ISD51 Demo (11.059MHz) (MCS-51)
  device: MSC1210Y5 Texas Instruments
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0x00-0x3FF) CLOCK(24000000) MODDP2
  output: ISD51_Demo +hex
  c flags: Optimize=7 SizeSpeed=1
  c define: MHz11
  group Applicaiton Source Files
    ./: Test.c HWCfr.a51 ROM.A51
  group ISD51 Files
    ./: ISD51.h ISD51.A51
  group Documentation
    ./: Abstract.txt
target ISD51 Demo (1.840MHz) (MCS-51)
  device: MSC1210Y5 Texas Instruments
  cpu: as above
  output: ISD51_Demo +hex
  c flags: Optimize=7 SizeSpeed=1
  c define: XTAL=1843200
