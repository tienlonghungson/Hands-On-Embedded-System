# Keil uVision project ISD51_Demo.uvproj, settings and files
target ISD51 Demo (MCS-51)
  device: nRF24E1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(16000000) MODDP2
  output: ISD51_Demo +hex
  c flags: Optimize=9 SizeSpeed=1
  group Application Source Files
    ./: Test.c
  group ISD51 Files
    ./: ISD51.A51 ISD51.H
