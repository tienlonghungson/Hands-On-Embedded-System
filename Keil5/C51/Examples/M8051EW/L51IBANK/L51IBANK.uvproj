# Keil uVision project L51IBANK.uvproj, settings and files
target Standard (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: L51IBANK +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: C_root.c C_bank0.c C_bank1.c C_bank2.c L51IBank.a51
  group Documentation
    ./: Abstract.txt
