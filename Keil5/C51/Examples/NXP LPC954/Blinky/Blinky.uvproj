# Keil uVision project Blinky.uvproj, settings and files
target Simulator (MCS-51)
  device: P89LPC954 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0-0xFF) CLOCK(18000000) MODP2
  output: Blinky +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Blinky.c
  group Startup Code
    ./: START954.A51
  group Documentation
    ./: ABSTRACT.TXT
target ULINK2 NXP LPC95x (MCS-51)
  device: P89LPC954 NXP (founded by Philips)
  cpu: as above
  output: Blinky +hex
  c flags: Optimize=8 SizeSpeed=1
target FS2 System Navigator (MCS-51)
  device: P89LPC954 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM (0-0xFF) CLOCK(18000000) MODP2
  output: Blinky +hex
  c flags: Optimize=8 SizeSpeed=1
