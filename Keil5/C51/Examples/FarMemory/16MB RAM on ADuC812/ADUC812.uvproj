# Keil uVision project ADUC812.uvproj, settings and files
target ADuC812 16MB RAM (MCS-51)
  device: ADuC812 Analog Devices
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(12000000) DPX
  output: LARGE_RAM
  c flags: Optimize=3 SizeSpeed=1
  asm misc: LINES
  group Source Files
    ./: MAIN.C XBANKING.A51
  group Documentation
    ./: ABSTRACT.TXT
