# Keil uVision project Far8051.uvproj, settings and files
target 4MB Variables on Classic 8051 (MCS-51)
  device: DS80C320 Dallas Semiconductor
  cpu: IRAM(0 - 0xFF) CLOCK(33000000) MODDP2
  output: Far8051 +hex
  c flags: Optimize=9 SizeSpeed=1
  asm misc: LINES
  group Source Files
    ./: MAIN.C L51_BANK.A51 Variables.c
  group Documentation
    ./: ABSTRACT.TXT
