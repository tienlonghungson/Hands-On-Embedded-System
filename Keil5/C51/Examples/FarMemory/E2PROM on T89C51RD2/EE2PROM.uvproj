# Keil uVision project EE2PROM.uvproj, settings and files
target 89C51RD2 eeprom demo (MCS-51)
  device: AT89C51RD2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0x6FF) CLOCK(33000000) MODP2
  output: EE2PROM
  c flags: Optimize=8 SizeSpeed=1
  asm misc: LINES
  group Source Files
    ./: MAIN.C XBANKING.A51 eeprom.c
  group Documentation
    ./: ABSTRACT.TXT
