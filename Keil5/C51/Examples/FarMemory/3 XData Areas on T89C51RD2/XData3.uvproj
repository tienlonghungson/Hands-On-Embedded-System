# Keil uVision project XData3.uvproj, settings and files
target 3 XData Areas on T89C51RD2 (MCS-51)
  device: AT89C51ED2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x6FF) CLOCK(33000000) MODP2
  output: XData3
  c flags: Optimize=8 SizeSpeed=1
  asm misc: LINES
  group Source Files
    ./: MAIN.C XBANKING.A51 Eeprom.c
  group Documentation
    ./: ABSTRACT.TXT
