# Keil uVision project WHETS.uvproj, settings and files
target Simulator (MCS-51)
  device: C8051F000 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(20000000)
  output: Whets +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Code
    ./: Whets.c Time.c
  group Documentation
    ./: Abstract.txt
