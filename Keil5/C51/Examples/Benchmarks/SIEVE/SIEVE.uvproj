# Keil uVision project SIEVE.uvproj, settings and files
target Small Model (MCS-51)
  device: 80C51FA NXP (founded by Philips)
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODP2
  output: Sieve +hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Code
    ./: Sieve.c
  group Documentation
    ./: Abstract.txt
target Large Model (MCS-51)
  device: 80C51FA NXP (founded by Philips)
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODP2
  output: Sieve
  c flags: Optimize=6 SizeSpeed=1
