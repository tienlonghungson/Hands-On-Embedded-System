# Keil uVision project DHRY.uvproj, settings and files
target Simulator: Large Model (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0 - 0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: Dhry +hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Code
    ./: DHRY.C TIME.C
  group Documentation
    ./: ABSTRACT.TXT README.C
