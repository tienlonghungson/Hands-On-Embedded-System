# Keil uVision project readable RTC.uvproj, settings and files
target Simulator (MCS-51)
  device: P89LPC985 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(12000000) MODP2
  output: readable RTC +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Test_RTC.c
  group Startup Code
    ./: START98x.A51
  group Documentation
    ./: ABSTRACT.TXT
