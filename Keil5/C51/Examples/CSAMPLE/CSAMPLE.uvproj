# Keil uVision project CSAMPLE.uvproj, settings and files
target Standard (MCS-51)
  device: C501G-L Infineon
  cpu: IRAM(0 - 0xFF) CLOCK(40000000)
  output: CSample +hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Code
    ./: CSAMPLE1.C CSAMPLE2.C CSAMPLE3.C
  group Documentation
    ./: ABSTRACT.TXT
