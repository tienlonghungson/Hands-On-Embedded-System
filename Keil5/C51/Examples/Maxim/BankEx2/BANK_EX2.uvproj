# Keil uVision project BANK_EX2.uvproj, settings and files
target Standard (MCS-51)
  device: 71M6534H Maxim
  cpu: IRAM(0-0xFF) IROM(0-0x3FFFF) XRAM(0-0xFFF) CLOCK(10000000) MODC2
  output: Bank_ex1 +hex
  c flags: SizeSpeed=1
  group Source Files
    ./: C_root.c C_bank0.c C_bank1.c C_bank2.c C_bank3.c C_bank4.c C_bank5.c C_bank6.c L51_71M65xx_8B.A51
  group Documentation
    ./: Abstract.txt
