# Keil uVision project BANK_EX1.uvproj, settings and files
target Standard (MCS-51)
  device: 71M6543G Maxim
  cpu: IRAM(0-0xFF) XRAM(0x28-0x13FF) IROM(0-0x1FFFF) CLOCK(5000000)  MODC2
  output: Bank_ex1 +hex
  c flags: SizeSpeed=1
  group Source Files
    ./: C_root.c C_bank1.c C_bank2.c C_bank0.c L51_MAXIM_4B.A51
  group Documentation
    ./: Abstract.txt
