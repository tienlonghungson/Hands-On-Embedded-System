# Keil uVision project CC6.uvproj, settings and files
target Simulator (MCS-51)
  device: XC866-4FR Infineon
  cpu: IRAM(0-0xFF) XRAM(0xF000-0xF1FF) IROM(0-0x2FFF) IROM2(0xA000-0xAFFF) CLOCK(4000000) MOD517DP
  output: CC6 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Dave Files
    ./: MAIN.C IO.C T01.C T2.C CC6.C SSC.c START_XC.A51
  group User Files
    ./: CC6.COD
  group Documentation
    ./: Abstract.txt
target Target via ULINK (MCS-51)
  device: XC866 Infineon
  cpu: IRAM(0-0xFF) XRAM(0xFF00-0xFFFF) IROM(0-0x1FFF) CLOCK(40000000) MOD517DP
  output: CC6 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: NOAJMP, REMOVEUNUSED
target Target via DAS Server (MCS-51)
  device: XC866 Infineon
  cpu: as above
  output: CC6 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: NOAJMP, REMOVEUNUSED
