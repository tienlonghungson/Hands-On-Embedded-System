# Keil uVision project ADC.uvproj, settings and files
target Simulator (MCS-51)
  device: XC866-4FR Infineon
  cpu: IRAM(0-0xFF) XRAM(0xF000-0xF1FF) IROM(0-0x2FFF) IROM2(0xA000-0xAFFF) CLOCK(4000000) MOD517DP
  output: ADC +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: IO.C MAIN.C ADC.C START_XC.A51
  group Simulation Scripts
    ./: Simulator.ini
  group Documentation
    ./: Abstract.txt
target Target via ULINK (MCS-51)
  device: XC866-4FR Infineon
  cpu: as above
  output: ADC +hex
  c flags: Optimize=8 SizeSpeed=1
target Target via DAS Server (MCS-51)
  device: XC866-4FR Infineon
  cpu: as above
  output: ADC +hex
  c flags: Optimize=8 SizeSpeed=1
