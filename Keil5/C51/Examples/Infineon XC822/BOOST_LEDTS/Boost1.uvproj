# Keil uVision project Boost1.uvproj, settings and files
target EasyKit XC822 (MCS-51)
  device: XC822M-1F Infineon
  cpu: IRAM(0-0xFF) XRAM(0xF000-0xF1FF) IROM(0-0x0FFF) CLOCK(24000000) MOD517DP
  output: Boost1 +hex
  c flags: Optimize=3 SizeSpeed=1
  group Startup
    ./: BOOTROM_ADDR.A51 START_XC82x.A51
  group Source
    ./: ADC.C CC6.C LTS.C MAIN.C SHARED_INT.C T2.C UART.C
  group Documentation
    ./: Abstract.txt
