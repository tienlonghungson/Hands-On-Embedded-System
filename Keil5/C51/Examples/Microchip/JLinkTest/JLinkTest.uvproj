# Keil uVision project JLinkTest.uvproj, settings and files
target Target 1 (MCS-51)
  device: IS2083B Microchip
  cpu: IRAM(0-0xFF) IROM(0-0xCFFFF)  IROM2(0x200000-0x27FFFF) IROM3(0x400000-0x5FFFFF) CLOCK(40000000) MOD_CONT MODDP2 XRAM(0x0000-0x11FFF) XRAM2(0x200000-0x27FFFF) XRAM3(0x400000-0x5FFFFF)
  output: JLinkTest +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: START_IS208x.A51 Main.c TestBlink.c
  group Documentation
    ./: ABSTRACT.TXT
