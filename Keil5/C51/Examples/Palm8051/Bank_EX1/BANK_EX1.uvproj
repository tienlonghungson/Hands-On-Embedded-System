# Keil uVision project BANK_EX1.uvproj, settings and files
target Standard (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Bank_ex1 +hex
  c flags: SizeSpeed=1
  group Source Files
    ./: C_root.c C_bank1.c C_bank2.c C_bank0.c L51_PALM_BANK.A51
  group Documentation
    ./: Abstract.txt
