# Keil uVision project ASAMPLE.uvproj, settings and files
target Simulator (MCS-51)
  device: 80C51FA Intel
  cpu: IRAM(0 - 0xFF) CLOCK(20000000)
  output: Asample
  c flags: Optimize=6 SizeSpeed=1
  group Source Files
    ./: ASAMPLE1.A51 ASAMPLE2.A51 ASAMPLE3.A51
  group Documentation
    ./: Abstract.txt
