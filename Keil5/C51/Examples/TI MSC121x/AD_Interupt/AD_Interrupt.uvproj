# Keil uVision project AD_Interrupt.uvproj, settings and files
target ISD51 - DAQ - 1.84MHz (MCS-51)
  device: MSC1210Y5 Texas Instruments
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0x00-0x3FF) CLOCK(24000000) MODDP2
  output: AD_Interrupt +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: XTAL=1843200, ISD51
  group Source Files
    ./: AD_Interrupt.c HWCfr.a51
  group Documentation
    ./: ABSTRACT.txt
  group Debugger Script
    ./: Debugger.INI
  group ISD51
    ./: ISD51.A51
target ISD51 - EVM - 11.0592MHz (MCS-51)
  device: MSC1210Y5 Texas Instruments
  cpu: as above
  output: AD_Interrupt +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: ISD51
target Simulator (MCS-51)
  device: MSC1210Y5 Texas Instruments
  cpu: as above
  output: AD_Interrupt +hex
  c flags: Optimize=8 SizeSpeed=1
