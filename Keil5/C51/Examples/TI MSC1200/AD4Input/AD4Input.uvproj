# Keil uVision project AD4Input.uvproj, settings and files
target ISD51 - EVM - 22.1184MHz (MCS-51)
  device: MSC1200Y3 Texas Instruments
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODDP2
  output: AD4Input +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: ISD51
  group Source Files
    ./: AD4Input.c HWCfr.a51 MSC1200_ROM.A51
  group Documentation
    ./: ABSTRACT.txt
  group Debugger Script
    ./: Debugger.INI
  group ISD51
    ./: ISD51.A51
target Simulator (MCS-51)
  device: MSC1200Y3 Texas Instruments
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODDP2
  output: AD4Input +hex
  c flags: Optimize=8 SizeSpeed=1
