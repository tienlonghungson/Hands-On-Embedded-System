# Keil uVision project Quick_Test.uvproj, settings and files
target 9832_Quick_Test (MCS-51)
  device: TLE 9832 Infineon
  cpu: IRAM(0-0xFF) XRAM(0xF000-0xFC00) IROM(0-0x07FFF) CLOCK(24000000) MOD517DP
  output: 9832_Quick_Test +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: TLE9832
  asm define: TLE9832
  group Configuration
    ./: START_TLE983x.A51 config_NAC_NAD.a51
  group Source
    ./: MAIN.C IO.C T01.C
  group Documentation
    ./: Abstract.txt
