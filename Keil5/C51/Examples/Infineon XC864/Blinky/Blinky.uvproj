# Keil uVision project Blinky.uvproj, settings and files
target Simulator (MCS-51)
  device: XC864-1FRI Infineon
  cpu: IRAM(0-0xFF) XRAM(0xF000-0xF1FF) IROM(0-0x0FFF) CLOCK(4000000) MOD517DP
  output: Blinky
  c flags: Optimize=8 SizeSpeed=1
  link misc: NOAJMP
  group Dave Files
    ./: START_XC.A51 MAIN.C T01.C IO.C UART.C
  group Documentation
    ./: Abstract.txt
target Target via ULINK (MCS-51)
  device: XC864-1FRI Infineon
  cpu: as above
  output: Blinky
  c flags: Optimize=8 SizeSpeed=1
  link misc: NOAJMP
target Target via DAS Server (MCS-51)
  device: XC864-1FRI Infineon
  cpu: as above
  output: Blinky
  c flags: Optimize=8 SizeSpeed=1
  link misc: NOAJMP
