# Keil uVision project Alarm_Clock.uvproj, settings and files
target Easy Kit XC836 (MCS-51)
  device: XC836MT-2F Infineon
  cpu: IRAM(0-0xFF) XRAM(0xF000-0xF1FF) IROM(0-0x1FFF) IROM2(0xFF40-0xFF80) CLOCK(24000000) MOD517DP
  output: Alarm_Clock +hex
  c flags: Optimize=3 SizeSpeed=1
  group Source
    ./: LTS.C MAIN.C RTC.C SHARED_INT.C T2.C
  group Startup
    ./: BOOTROM_ADDR.A51 START_XC82x.A51
  group Documentation
    ./: Abstract.txt
