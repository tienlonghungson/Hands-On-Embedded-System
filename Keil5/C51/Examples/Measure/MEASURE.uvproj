# Keil uVision project MEASURE.uvproj, settings and files
target Demo - Simulator (MCS-51)
  device: P89LPC935 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM (0-0x1FF) CLOCK(12000000) MODP2
  output: measure +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Code
    ./: Measure.c Mcommand.c Getline.c
  group Startup Code
    ./: START900.A51
  group Documentation
    ./: ABSTRACT.TXT
target Simulator (MCS-51)
  device: P89LPC935 NXP (founded by Philips)
  cpu: as above
  output: measure +hex
  c flags: Optimize=9 SizeSpeed=1
target MCB900 - Run (MCS-51)
  device: P89LPC935 NXP (founded by Philips)
  cpu: as above
  output: measure +hex
  c flags: Optimize=9 SizeSpeed=1
target EPM900 - Emulator (MCS-51)
  device: P89LPC935 NXP (founded by Philips)
  cpu: as above
  output: measure +hex
  c flags: Optimize=7 SizeSpeed=1
