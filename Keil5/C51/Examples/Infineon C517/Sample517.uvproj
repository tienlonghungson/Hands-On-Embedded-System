# Keil uVision project Sample517.uvproj, settings and files
target Simulator (MCS-51)
  device: SAB 80C517A Infineon
  cpu: IRAM(0 - 0xFF) CLOCK(18000000) MOD517DP MOD517AU XRAM (0xF800-0xFFFF)
  output: Sample517 +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Code
    ./: Sampl517.c Putchar.c Getkey.c
  group Documentation
    ./: Abstract.txt
target MCB517AC (MCS-51)
  device: C517A-L Infineon
  cpu: IRAM(0 - 0xFF) CLOCK(24000000) MOD517DP MOD517AU XRAM (0xF800-0xFFFF)
  output: Sample517
  c flags: Optimize=8 SizeSpeed=1
  c define: MONITOR51
