# Keil uVision project DK3200_1.uvproj, settings and files
target DK3200_1 (MCS-51)
  device: uPSD3234A STMicroelectronics
  cpu: IRAM(0-0xFF) CLOCK(40000000)  XRAM (0x2000-0x3FFF)
  output: DK3200_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source_Files
    ./: DK3200_1_demo.c Startu32.a51 upsd3200_lcd.c upsd3200_timer.c upsd3200_adc.c upsd3200_pwm.c
  group ISD
    ./: Isd51_U1.o
