# Keil uVision project led_blink.uvproj, settings and files
target led_blink (MCS-51)
  device: uPSD3234A STMicroelectronics
  cpu: IRAM(0-0xFF) CLOCK(40000000)  XRAM (0x2000-0x3FFF)
  output: led_blink +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led_blink.c upsd3200_timer.c Startu32.a51
