# Keil uVision project banking.uvproj, settings and files
target Banking (MCS-51)
  device: uPSD3334D STMicroelectronics
  cpu: IRAM(0 - 0xFF) CLOCK(40000000) XRAM(0xFF00 - 0xFFFF) MODH2
  output: banking +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Key.c banking.c st85.c Bank4.c Bank3.c Bank2.c Bank1.c Bank0.c upsd3300_lcd.c upsd3300_timer.c Encoder.c upsd3300_I2C.c upsd3300_SPI.c upsd3300_pca-pwm.c upsd3300_adc.c l51_bank.a51 startup33.a51 benchmark.a51
