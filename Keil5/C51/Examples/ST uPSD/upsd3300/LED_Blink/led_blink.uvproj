# Keil uVision project led_blink.uvproj, settings and files
target Target 1 (MCS-51)
  device: uPSD3334D STMicroelectronics
  cpu: IRAM(0 - 0xFF) CLOCK(40000000) XRAM(0xFF00 - 0xFFFF) MODH2
  output: led_blink +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led_blink.c upsd3300_timer.c startup33.a51
