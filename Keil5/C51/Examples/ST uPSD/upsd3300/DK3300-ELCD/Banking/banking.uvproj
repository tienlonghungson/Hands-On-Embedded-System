# Keil uVision project banking.uvproj, settings and files
target Banking (MCS-51)
  device: uPSD3433E STMicroelectronics
  cpu: IRAM(0-0xFF) CLOCK(40000000) XRAM(0x2000-0x3FFF) MODH2
  output: banking +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: banking.c Bank0.c Bank1.c Bank2.c Bank3.c Bank4.c upsd3300_timer.c upsd3300_pca-pwm.c upsd3300_adc.c l51_bank.a51 benchmark.a51 upsd3300_lcd.c startup33.a51 Key.c Encoder.c upsd3300_I2C.c st87.c
