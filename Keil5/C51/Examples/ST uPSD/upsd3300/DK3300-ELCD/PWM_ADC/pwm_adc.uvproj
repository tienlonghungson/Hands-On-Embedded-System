# Keil uVision project pwm_adc.uvproj, settings and files
target pwm_adc (MCS-51)
  device: uPSD3334D STMicroelectronics
  cpu: IRAM(0 - 0xFF) CLOCK(40000000) XRAM(0xFF00 - 0xFFFF) MODH2
  output: pwm_adc +hex
  c flags: Optimize=9
  group Source Group 1
    ./: upsd3300_timer.c pwm_adc.c upsd3300_adc.c upsd3300_lcd.c upsd3300_pca-pwm.c Startup33.a51
