# Keil uVision project eeprom_emul.uvproj, settings and files
target EEPROM Emulation (MCS-51)
  device: uPSD3334D STMicroelectronics
  cpu: IRAM(0 - 0xFF) CLOCK(40000000) XRAM(0xFF00 - 0xFFFF) MODH2
  output: eeprom_emul +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: eeprom_emul_demo.c eeprom.c upsd3300_timer.c startup33.a51 upsd3300_lcd.c
