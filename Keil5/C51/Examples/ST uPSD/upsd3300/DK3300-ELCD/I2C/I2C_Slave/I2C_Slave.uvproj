# Keil uVision project I2C_Slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: uPSD3334D STMicroelectronics
  cpu: IRAM(0 - 0xFF) CLOCK(40000000) XRAM(0xFF00 - 0xFFFF) MODH2
  output: I2C_Slave +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: upsd3300_timer.c I2C_Slave.c upsd3300_i2c.c Startup33.a51 upsd3300_lcd.c
