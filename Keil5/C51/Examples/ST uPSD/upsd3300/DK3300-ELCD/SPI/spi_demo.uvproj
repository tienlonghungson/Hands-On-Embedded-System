# Keil uVision project spi_demo.uvproj, settings and files
target SPI Demo (MCS-51)
  device: uPSD3334D STMicroelectronics
  cpu: IRAM(0 - 0xFF) CLOCK(40000000) XRAM(0xFF00 - 0xFFFF) MODH2
  output: spi_demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: spi_demo.c upsd3300_spi.c upsd3300_timer.c upsd3300_lcd.c Startup33.a51
