# Keil uVision project pwm_adc.uvproj, settings and files
target Target 1 (MCS-51)
  device: uPSD3334D STMicroelectronics
  cpu: IRAM(0 - 0xFF) CLOCK(40000000) XRAM(0xFF00 - 0xFFFF) MODH2
  output: pwm_adc +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: pwm_adc.c upsd3300_adc.c upsd3300_pca-pwm.c upsd3300_timer.c upsd3300_lcd.c startup33.a51
