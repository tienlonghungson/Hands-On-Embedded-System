# Keil uVision project lcd_demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: uPSD3434E STMicroelectronics
  cpu: IRAM(0 - 0xFF) CLOCK(40000000) XRAM(0x2000 - 0x3FFF) MODH2
  output: lcd_demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Startup
    ./: STARTUP34.A51
  group Source
    ./: upsd3400_timer.c LCD_demo.c upsd3400_lcd.c
