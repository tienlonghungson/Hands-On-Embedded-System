# Keil uVision project led_blink.uvproj, settings and files
target Target: DK3400 (MCS-51)
  device: uPSD3434E STMicroelectronics
  cpu: IRAM(0 - 0xFF) CLOCK(40000000) XRAM(0x2000 - 0x3FFF) MODH2
  output: led_blink +hex
  c flags: Optimize=8 SizeSpeed=1
  group Startup
    ./: STARTUP34.A51
  group Source
    ./: upsd3400_timer.c led_blink.c
target Simulation (MCS-51)
  device: uPSD3434E STMicroelectronics
  cpu: IRAM(0 - 0xFF) CLOCK(40000000) XRAM(0x2000 - 0x3FFF) MODH2
  output: led_blink +hex
  c flags: Optimize=8 SizeSpeed=1
