# Keil uVision project Blinky.uvproj, settings and files
target Simulator (MCS-51)
  device: ADuC834 Analog Devices
  cpu: IRAM(0 - 0xFF) XRAM(0xFF-8FF) IROM(0 - 0xF7FF) CLOCK(32768) DPX MODAB2
  output: Blinky +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Main.c
  group Startup Code
    ./: START_AD.A51
  group Documentation
    ./: ABSTRACT.TXT
target Target Debugging (MCS-51)
  device: ADuC834 Analog Devices
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0xF7FF) CLOCK(32768) DPX MODAB2
  output: Blinky +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: TARGET_DEBUGGING
