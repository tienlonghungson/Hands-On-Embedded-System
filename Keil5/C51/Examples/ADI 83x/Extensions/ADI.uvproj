# Keil uVision project ADI.uvproj, settings and files
target Simulator (MCS-51)
  device: ADuC834 Analog Devices
  cpu: IRAM(0 - 0xFF) XRAM(0xFF-8FF) IROM(0 - 0xF7FF) CLOCK(32768) DPX MODAB2
  output: ADI
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: START_AD.A51 ADI_B2.C XBANKING.A51
  group Documentation
    ./: ABSTRACT.TXT
