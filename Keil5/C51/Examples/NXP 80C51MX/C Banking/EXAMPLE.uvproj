# Keil uVision project EXAMPLE.uvproj, settings and files
target Standard (MCS-51)
  device: 8xC51MC2 NXP (founded by Philips)
  cpu: IRAM(0-0x1FF) IROM(0-0x17FFF) XRAM (0-0x9FF) CLOCK(24000000) MX
  output: Bank_ex1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: C_root.c C_bank1.c C_bank0.c Start_mx.a51 Mx51bank.a51
  group Documentation
    ./: Abstract.txt
target Extended Linker (MCS-51)
  device: P89C669 NXP (founded by Philips)
  cpu: IRAM(0-0x4FF) IROM(0-0x17FFF) XRAM (0-0x2FF) CLOCK(24000000) MX
  output: Bank_ex1 +hex
  c flags: Optimize=8 SizeSpeed=1
