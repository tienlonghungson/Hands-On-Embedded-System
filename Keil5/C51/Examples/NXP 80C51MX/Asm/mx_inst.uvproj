# Keil uVision project mx_inst.uvproj, settings and files
target Simulator (MCS-51)
  device: 8xC51MC2 NXP (founded by Philips)
  cpu: IRAM(0-0x1FF) IROM(0-0x17FFF) XRAM (0-0x9FF) CLOCK(24000000) MX
  output: mxjmps
  c flags: Optimize=8 SizeSpeed=1
  asm misc: MOD_MX51
  group Source Code
    ./: MX_INST.A51
