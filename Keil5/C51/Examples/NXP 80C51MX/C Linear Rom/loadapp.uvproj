# Keil uVision project loadapp.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8xC51MC2 NXP (founded by Philips)
  cpu: IRAM(0-0x1FF) IROM(0-0x17FFF) XRAM (0-0x9FF) CLOCK(24000000) MX
  output: loadapp +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main_b.c main_a.c int.c Start_mx.a51
  group Documentation
    ./: abstract.txt
