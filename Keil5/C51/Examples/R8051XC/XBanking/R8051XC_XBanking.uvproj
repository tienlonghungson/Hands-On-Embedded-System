# Keil uVision project R8051XC_XBanking.uvproj, settings and files
target 256KB Variables on R8051XC (MCS-51)
  device: R8051XC (2 DPTR) Evatronix
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MODC2 MDU_R515
  output: R8051XC_XBanking +hex
  c flags: Optimize=9 SizeSpeed=1
  asm misc: LINES
  group Source Files
    ./: MAIN.C Variables.c XBANKING.A51
  group Documentation
    ./: ABSTRACT.TXT
