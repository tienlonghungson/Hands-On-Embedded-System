# Keil uVision project test_xc.uvproj, settings and files
target Target 1 (MCS-51)
  device: R8051XC (8 DPTR) Evatronix
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: test_xc
  c flags: Optimize=8
  c misc: BSE
  group Source Group 1
    ./: STARTUP.A51 test_xc.c xcpy.a51
