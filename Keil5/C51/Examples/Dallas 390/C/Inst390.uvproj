# Keil uVision project Inst390.uvproj, settings and files
target Simulator (MCS-51)
  device: DS80C390 Dallas Semiconductor
  cpu: IRAM(0 - 0xFF) CLOCK(40000000) MOD_CONT MODDA MODDP2 XRAM (0xF000 - 0xFFFF)
  output: Inst390 +hex
  c flags: Optimize=8 SizeSpeed=1
  c misc: VARBANKING
  group Source Files
    ./: start390.a51 INIT.A51
    ../../Dallas 390/C/: BLINKY.C
  group Documentation
    ../: readme.txt
