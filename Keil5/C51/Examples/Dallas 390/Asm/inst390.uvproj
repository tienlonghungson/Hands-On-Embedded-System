# Keil uVision project inst390.uvproj, settings and files
target Simulator (MCS-51)
  device: DS80C390 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(40000000) MOD_CONT MODDA MODDP2 XRAM (0xF000-0xFFFF)
  output: INST390
  c flags: Optimize=8 SizeSpeed=1
  group Source Code
    ./: INST390.A51
