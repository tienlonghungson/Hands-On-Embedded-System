# Keil uVision project BANK_EX2.uvproj, settings and files
target Simulator (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: BANK_EX2
  c flags: Optimize=6 SizeSpeed=1
  link misc: BANK0(?CO?C_MESS0(8000H)) BANK1(?CO?C_MESS1(8000H))
  group Source Group 1
    ./: ABSTRACT.TXT L51_BANK.A51 C_PROG.C C_MESS0.C C_MESS1.C
