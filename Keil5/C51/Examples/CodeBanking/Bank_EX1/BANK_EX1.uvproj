# Keil uVision project BANK_EX1.uvproj, settings and files
target Standard (MCS-51)
  device: C501 Infineon
  cpu: IRAM(0-0xFF)  CLOCK(40000000)
  output: Bank_ex1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: C_root.c C_bank1.c C_bank2.c C_bank0.c L51_bank.a51
  group Documentation
    ./: Abstract.txt
