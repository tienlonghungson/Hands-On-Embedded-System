# Keil uVision project BANK_EX3.uvproj, settings and files
target Simulator (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: BANK_EX3
  c flags: Optimize=6 SizeSpeed=1
  link misc: COMMON(?PR?TIMER0?C_MODUL) BANK1(?PR?TINIT?C_MODUL(8000H))
  group Source Group 1
    ./: L51_BANK.A51 C_MODUL.C
