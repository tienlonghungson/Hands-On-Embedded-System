ORG 0000h
	MOV P1, #0ffh 
	MOV P0 ,#00
POLL:
	MOV A,P1
	//CJNE A,#00h,ALARM
	JNZ ALARM
	JZ ALARM_OFF
	LJMP POLL
ALARM :
	SETB P0.7
	//LJMP POLL
	SJMP FST_DOOR
FST_DOOR:
	CJNE A,#01h,SND_DOOR
	MOV P0, #0F9h
	LJMP POLL
SND_DOOR:
	CJNE A,#02h,THD_DOOR
	MOV P0,#0A4h
	LJMP POLL
THD_DOOR:
	CJNE A,#04h,FTH_DOOR
	MOV P0,#0B0h
	LJMP POLL
FTH_DOOR:
	MOV P0,#99h
	LJMP POLL
ALARM_OFF :
	CLR P0.7
	MOV P0,#00
	LJMP POLL
END_LOOP:
	LJMP END_LOOP
END